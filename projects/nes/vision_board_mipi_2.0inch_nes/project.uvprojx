# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread/components/drivers/include;rt-thread/components/libc/posix/io/poll;rt-thread/components/libc/compilers/common/include;rt-thread/components/dfs/dfs_v1/filesystems/elmfat;rt-thread/components/drivers/include;rt-thread/libcpu/arm/cortex-m85;rt-thread/components/drivers/include;packages/tinyusb/src;rt-thread/components/drivers/include;board;rt-thread/libcpu/arm/common;board/ports/nes;libraries/HAL_Drivers;rt-thread/components/libc/compilers/common/extension/fcntl/octal;rt-thread/components/libc/compilers/common/extension;rt-thread/include;libraries/HAL_Drivers/config;board/ports/mipi_lcd;rt-thread/components/dfs/dfs_v1/filesystems/devfs;rt-thread/components/dfs/dfs_v1/include;board/ports/nes/port;rt-thread/components/finsh;board/ports/nes/inc;rt-thread/components/drivers/include;.;rt-thread/components/libc/posix/io/epoll;packages/tinyusb/lib/rt-thread;board/ports;rt-thread/components/libc/posix/ipc;rt-thread/components/libc/posix/io/eventfd
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sdhi.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_parse.c shell.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group nes
    board/ports/nes/src/: nes_ppu.c nes_cpu.c nes.c nes_mapper.c nes_rom.c nes_apu.c
    board/ports/nes/src/nes_mapper/: nes_mapper3.c nes_mapper2.c nes_mapper0.c
    board/ports/nes/port/: nes_port.c rt_key_scan.c
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c xpad_joystick.c
    packages/tinyusb/lib/rt-thread/: tusb_rt_thread_port.c
    packages/tinyusb/src/class/hid/: hid_host.c
    packages/tinyusb/src/class/vendor/: vendor_host.c
    packages/tinyusb/src/common/: tusb_fifo.c
    packages/tinyusb/src/host/: hub.c usbh.c
    packages/tinyusb/src/portable/renesas/rusb2/: hcd_rusb2.c rusb2_common.c
    packages/tinyusb/src/: tusb.c
software components: Flex Software:RA Configuration 1.0.0
